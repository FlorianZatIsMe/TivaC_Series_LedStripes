# Keil uVision project Test_1.uvprojx, settings and files
target TM4C123G (6190000::V6.19::ARMCLANG)
  device: TM4C1231H6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Test_1
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=5 wLevel=3
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  group Src
    ./: GPIO.c GPIO.h main.c UART.c UART.h LED.c LED.h PWM.c PWM.h QEI.c QEI.h unitTest.c unitTest.h os.c os.h I2C.c I2C.h Clock.h Clock.c NVIC.h SYSCTL.h testCpp.cpp testCpp.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
